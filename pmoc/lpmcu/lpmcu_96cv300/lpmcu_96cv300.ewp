# IAR project lpmcu_96cv300.ewp, settings and files
configuration Debug (8051, debug)
  General.OGChipSelectMenu: 8051 Generic 8051
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: .\src; ..\lpmcu_common; .\; ..\lpmcu_common\hdmitx
  ICC8051.CCOptLevel: 2
  ICC8051.CCOptStrategy: 0
  ICC8051.IccLang: 0
  XLINK.XclFile: .\lnk51ew_8051.xcl
configuration Release (8051)
  as the first configuration, except:
  General.RTConfigPath: xxx.h
  General.OGChipSelectMenu: 8052 Generic 8052
  ICC8051.CCDefines: NDEBUG
  ICC8051.CCOptLevel: 3
  A8051.ADefines: NDEBUG
  XLINK.XclFile: lnk0t.xcl
  group lpmcu_common
    ../lpmcu_common/: base.c gpio.c ir.c keyled.c keyled_ct1642.c keyled_ct1642_inner.c keyled_fd650.c timer.c
  group lpmcu_common/hdmitx
    ../lpmcu_common/hdmitx/: hal_hdmitx_cec.c mcu_hdmitx_cec.c
  group src
    src/: main.c
