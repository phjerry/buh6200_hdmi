<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\lpmcu_96cv300.ewp</path>
    </project>
    <batchBuild />
</workspace>
